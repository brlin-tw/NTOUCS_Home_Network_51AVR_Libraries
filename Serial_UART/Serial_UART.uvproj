# Keil uVision project Serial_UART.uvproj, settings and files
target Current (MCS-51)
  device: W78E58B Nuvoton
  cpu: IRAM(0-0xFF) XRAM=(0-0xFF) IROM(0-0x3FFF) CLOCK(40000000)
  output: main.exe +hex
  c flags: Optimize=8 SizeSpeed=1
  group main
    ./Source_code/: main.c
  group Project_configurations
    ./Source_code/Project_configurations/: Common_definitions.h
  group Flow_of_control
    ./Source_code/Flow_of_control/: Delay.c Delay.h Hang.c Hang.h
  group Serial_UART
    ./Source_code/Serial_UART/: Serial_UART.c Serial_UART.h
  group Timer_or_counter
    ./Source_code/Timer_or_counter/: Timer_or_counter.c Timer_or_counter.h
  group LED
    ./Source_code/LED/: LED.c LED.h
  group Hardware_configurations
    ./Source_code/Hardware_configurations/: NTOUCS_Home_Network_51AVR.c NTOUCS_Home_Network_51AVR.h
