# Keil uVision project Hardware_configurations.uvproj, settings and files
target Current (MCS-51)
  device: W78E58B Nuvoton
  cpu: IRAM(0-0xFF) XRAM=(0-0xFF) IROM(0-0x3FFF) CLOCK(40000000)
  output: main.exe +hex
  c flags: Optimize=8 SizeSpeed=1
  group Main_program
    ./Source_code/: main.c
  group Project_configurations
    ./Source_code/Project_configurations/: Common_definitions.h
  group Hardware_configurations
    ./Source_code/Hardware_configurations/: NTOUCS_Home_Network_51AVR.c NTOUCS_Home_Network_51AVR.h
