# Keil uVision project Seven_segment_display.uvproj, settings and files
target Current (MCS-51)
  device: W78E58B Nuvoton
  cpu: IRAM(0-0xFF) XRAM=(0-0xFF) IROM(0-0x3FFF) CLOCK(40000000)
  output: main.exe +hex
  c flags: Optimize=8 SizeSpeed=1
  group main
    ./Source_code/: main.c
  group Project_configurations
    ./Source_code/Project_configurations/: Common_definitions.h Ports_and_control_signals_NTOUCS_HN_Winbond_W78E58B.h
  group Seven_segment_display
    ./Source_code/Seven_segment_display/: Seven_segment_display.c Seven_segment_display.h
  group Flow_of_control
    ./Source_code/Flow_of_control/: Delay.c Delay.h Hang.c Hang.h
