# Keil uVision project ADC.uvproj, settings and files
target Current (MCS-51)
  device: W78E58B Nuvoton
  cpu: IRAM(0-0xFF) XRAM=(0-0xFF) IROM(0-0x3FFF) CLOCK(40000000)
  output: main.exe +hex
  c flags: Optimize=8 SizeSpeed=1
  group main
    ./Source_code/: main.c
  group Project_configurations
    ./Source_code/Project_configurations/: Common_definitions.h
  group ADC
    ./Source_code/ADC/: ADC.c
  group LED
    ../LED/Source_code/LED/: LED.c
