# Keil uVision project Timer_or_counter.uvproj, settings and files
target Current (MCS-51)
  device: W78E58B Nuvoton
  cpu: IRAM(0-0xFF) XRAM=(0-0xFF) IROM(0-0x3FFF) CLOCK(40000000)
  output: main.exe +hex
  c flags: Optimize=8 SizeSpeed=1
  group main
    ./Source_code/: main.c
  group Project_configurations
    ./Source_code/Project_configurations/: Common_definitions.h Ports_and_control_signals_NTOUCS_HN_Winbond_W78E58B.h
  group Flow_of_control
    ./Source_code/Flow_of_control/: Delay.c Delay.h Hang.c Hang.h
  group Timer_or_counter
    ./Source_code/Timer_or_counter/: Timer_or_counter.c Timer_or_counter.h
